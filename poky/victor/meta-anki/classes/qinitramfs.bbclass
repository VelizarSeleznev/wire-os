# Compatibility shim for Qualcomm initramfs image recipes.
#
# The recipe already inherits core-image and declares its package/image
# settings directly, so this class is intentionally empty.
